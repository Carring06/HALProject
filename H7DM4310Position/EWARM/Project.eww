<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\H7DM4310Position.ewp</path>
  </project>
  <batchBuild />
</workspace>
