# Keil uVision project HAL_Car.uvprojx, settings and files
target HAL_Car (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: HAL_Car +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/inc;../Algorithm;../MyDrivers;../Protections
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group User
    ../User/src/: BLE_Serial.c Encoder.c key.c LED.c Motor.c NRF24L01.c OLED.c OLED_Data.c vofa.c MyI2C.c MPU6050.c Delay.c
    ../User/inc/: BLE_Serial.h Encoder.h key.h LED.h Motor.h NRF24L01.h NRF24L01_Define.h OLED.h OLED_Data.h vofa.h MyI2C.h MPU6050.h MPU6050_Reg.h Delay.h
  group Algorithm
    ../Algorithm/: PID.c PID.h CompFilter.c CompFilter.h
  group MyDrivers
    ../MyDrivers/: Header.h Motor_driver.c Motor_driver.h BlueSerial_Debug.c BlueSerial_Debug.h ShowInOLED.c ShowInOLED.h
  group Protections
    ../Protections/: Motor_Protection.c Motor_Protection.h
software components: CMSIS:CORE 4.3.0
